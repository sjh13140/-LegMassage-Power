# Keil uVision project main.uvproj, settings and files
target test (MCS-51)
  device: TM52FN8276 tenx
  cpu: IRAM(0-0xFF) CLOCK(16000000) XRAM(0xFD00-0xFFFF)
  output: main +hex
  AfterMake: .\_MakeTenx_main\run.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\Drivers
  group Source Group 1
    ./: STARTUP_TENX52.A51
    ./src/: main.c ct1642.c uart1.c timer.c pwm.c output.c eeprom.c wdg.c input.c
    ./Drivers/: tm52fn8276_bsp.c
